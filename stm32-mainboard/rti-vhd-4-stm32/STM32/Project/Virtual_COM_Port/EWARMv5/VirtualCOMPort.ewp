# IAR project VirtualCOMPort.ewp, settings and files
configuration HMX_441_4K_Kit_usb (ARM)
  General.OGChipSelectEditMenu: STM32F10xxE ST STM32F10xxE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; USE_STM3210E_EVAL; PRD_USB_FUN
  ICCARM.CCIncludePath2: ..\inc; ..\LedModule; ..\IRModule; ..\KeyModule; ..\LcdModule; ..\SwitchVideoModule; ..\InputModule; ..\OutputModule; ..\UserRs232Module; ..\NVRAMModule; ..\CPLDModule; ..\MainApp; ..\..\..\Libraries\CMSIS\Core\CM3; ..\..\..\Libraries\STM32_USB-FS-Device_Driver\inc; ..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\..\Utilities\STM32_EVAL; ..\..\..\Utilities\STM32_EVAL\STM3210E_EVAL; ..\..\..\Project\Virtual_COM_Port\inc; ..\..\..\Project\Virtual_COM_Port\src; ..\..\..\Project\Virtual_COM_Port\Hardware; ..\..\..\Project\Virtual_COM_Port\SiI9396_Rx_Host_SVN36275_AVR_RX_w_Executable\application\rx; ..\..\..\Project\Virtual_COM_Port\SiI9396_Rx_Host_SVN36275_AVR_RX_w_Executable\framework; ..\..\..\Project\Virtual_COM_Port\SiI9396_Rx_Host_SVN36275_AVR_RX_w_Executable\framework\flash; ..\..\..\Project\Virtual_COM_Port\SiI9396_Rx_Host_SVN36275_AVR_RX_w_Executable\framework\ipc; ..\..\..\Project\Virtual_COM_Port\SiI9396_Rx_Host_SVN36275_AVR_RX_w_Executable\platform\hal; ..\..\..\Project\Virtual_COM_Port\SiI9396_Rx_Host_SVN36275_AVR_RX_w_Executable\platform\osal
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: HMX_441_4K_Kit_usb.bin
  ILINK.IlinkOutputFile: VirtualCOMPort.out
  ILINK.IlinkIcfFile: stm32f10x_flash_usb.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration HMX_441_4K_Kit_debug (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; USE_STM3210E_EVAL
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
configuration HMX_441_4K_kit_flash (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; USE_STM3210E_EVAL
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  group CMSIS
    ../../../Libraries/CMSIS/Core/CM3/: core_cm3.c system_stm32f10x.c
  group CPLDModule
    ../CPLDModule/: CPLDHandle.c CPLDReceiveEvent.c dvCPLD.c
  group Doc
    ../: readme.txt
  group EWARMv5
    ../../../Libraries/CMSIS/Core/CM3/startup/iar/: startup_stm32f10x_cl.s startup_stm32f10x_hd.s startup_stm32f10x_ld.s startup_stm32f10x_md.s
  group Hardware
    ../Hardware/: si_logger.c si_osal_timer.c si_timer.c
  group InputModule
    ../InputModule/: InputHandle.c InputReceiveEvent.c
  group IRModule
    ../IRModule/: IR.c IRhandle.c IRTasks.c
  group KeyModule
    ../KeyModule/: KeyEvent.c Keyhandle.c KeyTasks.c
  group LcdModule
    ../LcdModule/: dvLcd.c LcdHandle.c LcdReceiveEvent.c
  group LedModule
    ../LedModule/: dvTM1623.c LedHandle.c LedReceiveEvent.c
  group MainApp
    ../mainAPP/: mainapp.c
  group NVRAMMoudle
    ../NVRAMModule/: dvNVRAM.c utilCRC.c utilDataMgr.c
  group OutputModule
    ../OutputModule/: OutputHandle.c OutputReceiveEvent.c
  group Sil9396
    ../SiI9396_Rx_Host_SVN36275_AVR_RX_w_Executable/platform/hal/: device_host.c hal_aardvark_i2c.c
    ../SiI9396_Rx_Host_SVN36275_AVR_RX_w_Executable/framework/flash/: flash.c
    ../SiI9396_Rx_Host_SVN36275_AVR_RX_w_Executable/framework/ipc/: ipc.c ipc_api.c ipc_hal_host.c ipc_host.c
    ../SiI9396_Rx_Host_SVN36275_AVR_RX_w_Executable/platform/osal/: osal_win32.c
    ../SiI9396_Rx_Host_SVN36275_AVR_RX_w_Executable/framework/: sii_api.c
    ../SiI9396_Rx_Host_SVN36275_AVR_RX_w_Executable/application/rx/: sii_app_rx.c
  group StdPeriph_Driver
    ../../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group STM32_EVAL
    ../../../Utilities/STM32_EVAL/: stm32_eval.c
  group SwitchVideoModule
    ../SwitchVideoModule/: dvM21452.c SwitchVideoHandle.c SwitchVideoReceiveEvent.c
  group USB-FS-Device_Driver
    ../../../Libraries/STM32_USB-FS-Device_Driver/src/: otgd_fs_cal.c otgd_fs_dev.c otgd_fs_int.c otgd_fs_pcd.c usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
    ../src/: usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group User
    ../src/: appPowerMgr.c appSystemMgr.c appUserInterface.c bsp_Gpio.c BSP_I2c.c dv74ls138.c dvPC9539.c dvVS010TX.c EDID.c halPowerCtrl.c hw_config.c IAP.c initPeriph.c main.c ST25P16.C stm32f10x_it.c sys.c Uart2.c USB_process.c Util.c
  group UserRs323Module
    ../UserRs232Module/: CmdFunction.c uart.c UartRs232Tasks.c
