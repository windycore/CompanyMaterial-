# IAR project VirtualCOMPort.ewp, settings and files
configuration STM3210E-EVAL (ARM, debug)
  General.OGChipSelectEditMenu: STM32F10xxE ST STM32F10xxE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; USE_STM3210E_EVAL
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\Libraries\CMSIS\Core\CM3; ..\..\..\Libraries\STM32_USB-FS-Device_Driver\inc; ..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\..\Utilities\STM32_EVAL; ..\..\..\Utilities\STM32_EVAL\STM3210E_EVAL; ..\..\..\Project\Virtual_COM_Port\inc; ..\..\..\Project\Virtual_COM_Port\_9533\Application; ..\..\..\Project\Virtual_COM_Port\_9533\Application\app_cec; ..\..\..\Project\Virtual_COM_Port\_9533\Application\app_msw; ..\..\..\Project\Virtual_COM_Port\_9533\Application\app_thx; ..\..\..\Project\Virtual_COM_Port\_9533\component; ..\..\..\Project\Virtual_COM_Port\_9533\component\audio_rx; ..\..\..\Project\Virtual_COM_Port\_9533\component\cbus; ..\..\..\Project\Virtual_COM_Port\_9533\component\cdc; ..\..\..\Project\Virtual_COM_Port\_9533\component\cec_manager; ..\..\..\Project\Virtual_COM_Port\_9533\component\cec_switch; ..\..\..\Project\Virtual_COM_Port\_9533\component\cec_system_audio_control; ..\..\..\Project\Virtual_COM_Port\_9533\component\debugger_hdmigear; ..\..\..\Project\Virtual_COM_Port\_9533\component\edid_tx; ..\..\..\Project\Virtual_COM_Port\_9533\component\ipv; ..\..\..\Project\Virtual_COM_Port\_9533\component\osd; ..\..\..\Project\Virtual_COM_Port\_9533\component\repeater_avr; ..\..\..\Project\Virtual_COM_Port\_9533\component\rtpi; ..\..\..\Project\Virtual_COM_Port\_9533\component\thx; ..\..\..\Project\Virtual_COM_Port\_9533\component\tx; ..\..\..\Project\Virtual_COM_Port\_9533\component\video_tables; ..\..\..\Project\Virtual_COM_Port\_9533\driver; ..\..\..\Project\Virtual_COM_Port\_9533\driver\arc_drv; ..\..\..\Project\Virtual_COM_Port\_9533\driver\audio_mix_drv; ..\..\..\Project\Virtual_COM_Port\_9533\driver\audio_rx_drv; ..\..\..\Project\Virtual_COM_Port\_9533\driver\cbus_drv; ..\..\..\Project\Virtual_COM_Port\_9533\driver\cpi_drv; ..\..\..\Project\Virtual_COM_Port\_9533\driver\cra_drv; ..\..\..\Project\Virtual_COM_Port\_9533\driver\gpio_drv; ..\..\..\Project\Virtual_COM_Port\_9533\driver\ipv_drv; ..\..\..\Project\Virtual_COM_Port\_9533\driver\matrix_sw_drv; ..\..\..\Project\Virtual_COM_Port\_9533\driver\nvram_sram_drv; ..\..\..\Project\Virtual_COM_Port\_9533\driver\osd_drv; ..\..\..\Project\Virtual_COM_Port\_9533\driver\repeater_avr_drv; ..\..\..\Project\Virtual_COM_Port\_9533\driver\sii953x_drv; ..\..\..\Project\Virtual_COM_Port\_9533\driver\spi_drv; ..\..\..\Project\Virtual_COM_Port\_9533\driver\tpg_drv; ..\..\..\Project\Virtual_COM_Port\_9533\driver\tpi_drv; ..\..\..\Project\Virtual_COM_Port\_9533\HARDWARE\audio_dac; ..\..\..\Project\Virtual_COM_Port\_9533\HARDWARE\board; ..\..\..\Project\Virtual_COM_Port\_9533\HARDWARE\eeprom; ..\..\..\Project\Virtual_COM_Port\_9533\HARDWARE\idt5v9885t; ..\..\..\Project\Virtual_COM_Port\_9533\HARDWARE\IIC; ..\..\..\Project\Virtual_COM_Port\_9533\HARDWARE\timer; ..\..\..\Project\Virtual_COM_Port\_9533\HARDWARE\logger; ..\..\..\Project\Virtual_COM_Port\src; ..\..\..\Project\Virtual_COM_Port\sii9679\application_9679\rx_example; ..\..\..\Project\Virtual_COM_Port\sii9679\driver\adapter\adapter_api; ..\..\..\Project\Virtual_COM_Port\sii9679\driver\adapter\adapter_internal; ..\..\..\Project\Virtual_COM_Port\sii9679\driver\adapter\adapter_tx; ..\..\..\Project\Virtual_COM_Port\sii9679\driver\adapter\adapter_rx
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: VirtualCOMPort.bin
  ILINK.IlinkOutputFile: VirtualCOMPort.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM3210B-EVAL (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F10xxB ST STM32F10xxB
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD; USE_STM3210B_EVAL
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\Libraries\CMSIS\Core\CM3; ..\..\..\Libraries\STM32_USB-FS-Device_Driver\inc; ..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\..\Utilities\STM32_EVAL; ..\..\..\Utilities\STM32_EVAL\STM3210B_EVAL; ..\..\..\Project\Virtual_COM_Port\inc; ..\..\..\Project\Virtual_COM_Port\_9533\Application; ..\..\..\Project\Virtual_COM_Port\_9533\Application\app_cec; ..\..\..\Project\Virtual_COM_Port\_9533\Application\app_msw; ..\..\..\Project\Virtual_COM_Port\_9533\Application\app_thx; ..\..\..\Project\Virtual_COM_Port\_9533\component; ..\..\..\Project\Virtual_COM_Port\_9533\component\audio_rx; ..\..\..\Project\Virtual_COM_Port\_9533\component\cbus; ..\..\..\Project\Virtual_COM_Port\_9533\component\cdc; ..\..\..\Project\Virtual_COM_Port\_9533\component\cec_manager; ..\..\..\Project\Virtual_COM_Port\_9533\component\cec_switch; ..\..\..\Project\Virtual_COM_Port\_9533\component\cec_system_audio_control; ..\..\..\Project\Virtual_COM_Port\_9533\component\debugger_hdmigear; ..\..\..\Project\Virtual_COM_Port\_9533\component\edid_tx; ..\..\..\Project\Virtual_COM_Port\_9533\component\ipv; ..\..\..\Project\Virtual_COM_Port\_9533\component\osd; ..\..\..\Project\Virtual_COM_Port\_9533\component\repeater_avr; ..\..\..\Project\Virtual_COM_Port\_9533\component\rtpi; ..\..\..\Project\Virtual_COM_Port\_9533\component\thx; ..\..\..\Project\Virtual_COM_Port\_9533\component\tx; ..\..\..\Project\Virtual_COM_Port\_9533\component\video_tables; ..\..\..\Project\Virtual_COM_Port\_9533\driver; ..\..\..\Project\Virtual_COM_Port\_9533\driver\arc_drv; ..\..\..\Project\Virtual_COM_Port\_9533\driver\audio_mix_drv; ..\..\..\Project\Virtual_COM_Port\_9533\driver\audio_rx_drv; ..\..\..\Project\Virtual_COM_Port\_9533\driver\cbus_drv; ..\..\..\Project\Virtual_COM_Port\_9533\driver\cpi_drv; ..\..\..\Project\Virtual_COM_Port\_9533\driver\cra_drv; ..\..\..\Project\Virtual_COM_Port\_9533\driver\gpio_drv; ..\..\..\Project\Virtual_COM_Port\_9533\driver\ipv_drv; ..\..\..\Project\Virtual_COM_Port\_9533\driver\matrix_sw_drv; ..\..\..\Project\Virtual_COM_Port\_9533\driver\nvram_sram_drv; ..\..\..\Project\Virtual_COM_Port\_9533\driver\osd_drv; ..\..\..\Project\Virtual_COM_Port\_9533\driver\repeater_avr_drv; ..\..\..\Project\Virtual_COM_Port\_9533\driver\sii953x_drv; ..\..\..\Project\Virtual_COM_Port\_9533\driver\spi_drv; ..\..\..\Project\Virtual_COM_Port\_9533\driver\tpg_drv; ..\..\..\Project\Virtual_COM_Port\_9533\driver\tpi_drv; ..\..\..\Project\Virtual_COM_Port\_9533\HARDWARE\audio_dac; ..\..\..\Project\Virtual_COM_Port\_9533\HARDWARE\board; ..\..\..\Project\Virtual_COM_Port\_9533\HARDWARE\eeprom; ..\..\..\Project\Virtual_COM_Port\_9533\HARDWARE\idt5v9885t; ..\..\..\Project\Virtual_COM_Port\_9533\HARDWARE\IIC; ..\..\..\Project\Virtual_COM_Port\_9533\HARDWARE\timer; ..\..\..\Project\Virtual_COM_Port\_9533\HARDWARE\logger; ..\..\..\Project\Virtual_COM_Port\src
  ICCARM.CCOptLevel: 3
configuration STM3210C-EVAL (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F10xxC ST STM32F10xxC
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL; USE_STM3210C_EVAL
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\Libraries\CMSIS\Core\CM3; ..\..\..\Libraries\STM32_USB-FS-Device_Driver\inc; ..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\..\Utilities\STM32_EVAL; ..\..\..\Utilities\STM32_EVAL\STM3210C_EVAL
  ICCARM.CCOptLevel: 3
configuration STM3210E-EVAL-DEBUG (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; USE_STM3210E_EVAL; USE_FULL_ASSERT
configuration STM3210E-USB (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; USE_STM3210E_EVAL; PRD_USB_FUN
  OBJCOPY.OOCOutputFile: VirtualCOMPort_USB.bin
  ILINK.IlinkIcfFile: stm32f10x_flash_usb.icf
configuration STM3210E_EVAL_DEBUG_MUH44TPR2_N (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; USE_STM3210E_EVAL; USE_FULL_ASSERT; MUH44TPR2_N
configuration STM3210E-USB_MUH44TPR2_N (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; USE_STM3210E_EVAL; PRD_USB_FUN; MUH44TPR2_N
  OBJCOPY.OOCOutputFile: VirtualCOMPort_USB_MUH44TPR2_N.bin
  ILINK.IlinkIcfFile: stm32f10x_flash_usb.icf
configuration STM3210E-EVAL_MUH44TPR2_N (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; USE_STM3210E_EVAL; MUH44TPR2_N
configuration STM32-USB_RTI (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; USE_STM3210E_EVAL; PRD_USB_FUN; PRD_VHD4
  OBJCOPY.OOCOutputFile: VirtualCOMPort_USB_RTIVHD4.bin
  ILINK.IlinkIcfFile: stm32f10x_flash_usb.icf
configuration STM3210E-EVEL-DEBUG_RTI (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; USE_STM3210E_EVAL; USE_FULL_ASSERT; PRD_VHD4
configuration HMX_441_4K_Kit_usb (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\inc; ..\LedModule; ..\IRModule; ..\KeyModule; ..\LcdModule; ..\SwitchVideoModule; ..\InputModule; ..\UserRs232Module; ..\NVRAMModule; ..\MainApp; ..\..\..\Libraries\CMSIS\Core\CM3; ..\..\..\Libraries\STM32_USB-FS-Device_Driver\inc; ..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\..\Utilities\STM32_EVAL; ..\..\..\Utilities\STM32_EVAL\STM3210E_EVAL; ..\..\..\Project\Virtual_COM_Port\inc; ..\..\..\Project\Virtual_COM_Port\src; ..\..\..\Project\Virtual_COM_Port\_9533\Application; ..\..\..\Project\Virtual_COM_Port\_9533\Application\app_cec; ..\..\..\Project\Virtual_COM_Port\_9533\Application\app_msw; ..\..\..\Project\Virtual_COM_Port\_9533\Application\app_thx; ..\..\..\Project\Virtual_COM_Port\_9533\component; ..\..\..\Project\Virtual_COM_Port\_9533\component\audio_rx; ..\..\..\Project\Virtual_COM_Port\_9533\component\cbus; ..\..\..\Project\Virtual_COM_Port\_9533\component\cdc; ..\..\..\Project\Virtual_COM_Port\_9533\component\cec_manager; ..\..\..\Project\Virtual_COM_Port\_9533\component\cec_switch; ..\..\..\Project\Virtual_COM_Port\_9533\component\cec_system_audio_control; ..\..\..\Project\Virtual_COM_Port\_9533\component\debugger_hdmigear; ..\..\..\Project\Virtual_COM_Port\_9533\component\edid_tx; ..\..\..\Project\Virtual_COM_Port\_9533\component\ipv; ..\..\..\Project\Virtual_COM_Port\_9533\component\osd; ..\..\..\Project\Virtual_COM_Port\_9533\component\repeater_avr; ..\..\..\Project\Virtual_COM_Port\_9533\component\rtpi; ..\..\..\Project\Virtual_COM_Port\_9533\component\thx; ..\..\..\Project\Virtual_COM_Port\_9533\component\tx; ..\..\..\Project\Virtual_COM_Port\_9533\component\video_tables; ..\..\..\Project\Virtual_COM_Port\_9533\driver; ..\..\..\Project\Virtual_COM_Port\_9533\driver\arc_drv; ..\..\..\Project\Virtual_COM_Port\_9533\driver\audio_mix_drv; ..\..\..\Project\Virtual_COM_Port\_9533\driver\audio_rx_drv; ..\..\..\Project\Virtual_COM_Port\_9533\driver\cbus_drv; ..\..\..\Project\Virtual_COM_Port\_9533\driver\cpi_drv; ..\..\..\Project\Virtual_COM_Port\_9533\driver\cra_drv; ..\..\..\Project\Virtual_COM_Port\_9533\driver\gpio_drv; ..\..\..\Project\Virtual_COM_Port\_9533\driver\ipv_drv; ..\..\..\Project\Virtual_COM_Port\_9533\driver\matrix_sw_drv; ..\..\..\Project\Virtual_COM_Port\_9533\driver\nvram_sram_drv; ..\..\..\Project\Virtual_COM_Port\_9533\driver\osd_drv; ..\..\..\Project\Virtual_COM_Port\_9533\driver\repeater_avr_drv; ..\..\..\Project\Virtual_COM_Port\_9533\driver\sii953x_drv; ..\..\..\Project\Virtual_COM_Port\_9533\driver\spi_drv; ..\..\..\Project\Virtual_COM_Port\_9533\driver\tpg_drv; ..\..\..\Project\Virtual_COM_Port\_9533\driver\tpi_drv; ..\..\..\Project\Virtual_COM_Port\_9533\HARDWARE\audio_dac; ..\..\..\Project\Virtual_COM_Port\_9533\HARDWARE\board; ..\..\..\Project\Virtual_COM_Port\_9533\HARDWARE\eeprom; ..\..\..\Project\Virtual_COM_Port\_9533\HARDWARE\idt5v9885t; ..\..\..\Project\Virtual_COM_Port\_9533\HARDWARE\IIC; ..\..\..\Project\Virtual_COM_Port\_9533\HARDWARE\timer; ..\..\..\Project\Virtual_COM_Port\_9533\HARDWARE\logger; ..\..\..\Project\Virtual_COM_Port\InputModule\sii9679\application_9679\rx_example; ..\..\..\Project\Virtual_COM_Port\InputModule\sii9679\driver\adapter\adapter_api; ..\..\..\Project\Virtual_COM_Port\InputModule\sii9679\driver\adapter\adapter_internal; ..\..\..\Project\Virtual_COM_Port\InputModule\sii9679\driver\adapter\adapter_tx; ..\..\..\Project\Virtual_COM_Port\InputModule\sii9679\driver\adapter\adapter_rx
  OBJCOPY.OOCOutputFile: MHUB4K862_USB.bin
  ILINK.IlinkIcfFile: stm32f10x_flash_usb.icf
configuration HMX_441_4K_Kit_flash (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F10xxC ST STM32F10xxC
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD; USE_STM3210E_EVAL
  ICCARM.CCDiagSuppress: Pa050,Pe167
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: HMX_441_4K_Kit_usb.bin
  ILINK.IlinkIcfFile: E:\工作code\STM32\MUH88E\HMX_441_4K_Kit\rti-vhd-4-stm32\STM32\Project\Virtual_COM_Port\EWARMv5\stm32f10x_flash_2.icf
configuration MHUB4K862_USB (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F10xxC ST STM32F10xxC
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD; USE_STM3210E_EVAL; PRD_USB_FUN
  ICCARM.CCDiagSuppress: Pa050,Pe167
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: MHUB4K862_USB.bin
  ILINK.IlinkIcfFile: stm32f10x_flash_usb.icf
configuration MHUB4K862_FLASH (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F10xxC ST STM32F10xxC
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD; USE_STM3210E_EVAL; USE_FULL_ASSERT
  ICCARM.CCDiagSuppress: Pa050,Pe167
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: MHUB4K862_FLASH.bin
configuration MUHB4K431_DEBUG (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F10xxC ST STM32F10xxC
  ICCARM.CCDefines: as above
  ICCARM.CCDiagSuppress: Pa050,Pe167
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: MHUB4K862_FLASH.bin
  group 9533_App
    ../_9533/Application/: sk_app_audio_rx.c sk_app_device.c sk_app_edid.c sk_app_ediddata.c sk_app_repeater.c sk_app_support.c sk_app_tx.c sk_avr_repeater.c
    ../_9533/Application/app_cec/: sk_app_cec.c sk_app_cec_logger.c
    ../_9533/Application/app_msw/: sk_app_switch.c
    ../_9533/Application/app_thx/: sk_app_thx.c
  group 9533_Component
    ../_9533/component/audio_rx/: si_audio_component.c
    ../_9533/component/cec_manager/: si_cec_component.c si_cec_controller.c si_cec_rx.c si_cec_timer.c si_cec_tx.c
    ../_9533/component/repeater_avr/: si_connection_monitor.c si_repeater_component.c si_repeater_isr.c si_repeater_sha.c
    ../_9533/component/debugger_hdmigear/: si_debugger_hdmigear.c
    ../_9533/component/edid_tx/: si_edid_black_list.c si_edid_tx_analyzer.c si_edid_tx_component.c si_edid_tx_composer.c si_edid_tx_converter.c si_edid_tx_decode_h.c si_edid_tx_decode_l.c si_edid_tx_fmf.c si_edid_tx_scaler.c si_edid_tx_tables.c
    ../_9533/component/rtpi/: si_rtpi_cec.c si_rtpi_component.c si_rtpi_default_reg.c si_rtpi_register_functions.c
    ../_9533/component/thx/: si_thx_component.c
    ../_9533/component/tx/: si_tx_audio.c si_tx_avi.c si_tx_component.c si_tx_hdcp.c si_tx_info_frm.c si_tx_video.c
    ../_9533/component/video_tables/: si_video_tables.c
  group 9533_Driver
    ../_9533/driver/cra_drv/: si_cra.c
    ../_9533/driver/sii953x_drv/: si_cra_cfg.c si_drv_3dgpio.c si_drv_sii953x.c
    ../_9533/driver/audio_rx_drv/: si_drv_audio.c
    ../_9533/driver/audio_mix_drv/: si_drv_audio_mix.c
    ../_9533/driver/cpi_drv/: si_drv_cpi.c si_drv_cpi_regio.c
    ../_9533/driver/nvram_sram_drv/: si_drv_edid_rx.c si_drv_nvram_sram.c
    ../_9533/driver/gpio_drv/: si_drv_gpio.c
    ../_9533/driver/matrix_sw_drv/: si_drv_msw.c si_drv_msw_hpd.c si_drv_msw_info.c
    ../_9533/driver/repeater_avr_drv/: si_drv_repeater.c si_drv_repeater_sha.c
    ../_9533/driver/tpg_drv/: si_drv_tpg.c
    ../_9533/driver/tpi_drv/: si_drv_tpi_access.c si_drv_tpi_ddc_access.c si_drv_tpi_system.c
  group 9533_Hardware
    ../_9533/HARDWARE/: buildtime.c
    ../_9533/HARDWARE/eeprom/: si_eeprom.c
    ../_9533/HARDWARE/board/: si_gpio.c si_platform.c
    ../_9533/HARDWARE/IIC/: si_i2c.c
    ../_9533/HARDWARE/idt5v9885t/: si_idt_5v9885t.c
    ../_9533/HARDWARE/logger/: si_logger.c
    ../_9533/HARDWARE/timer/: si_osal_timer.c si_timer.c
  group CMSIS
    ../../../Libraries/CMSIS/Core/CM3/: core_cm3.c system_stm32f10x.c
  group Doc
    ../: readme.txt
  group EWARMv5
    ../../../Libraries/CMSIS/Core/CM3/startup/iar/: startup_stm32f10x_cl.s startup_stm32f10x_hd.s startup_stm32f10x_ld.s startup_stm32f10x_md.s
  group IRModule
    ../IRModule/: IR.c IRhandle.c IRTasks.c
  group KeyModule
    ../KeyModule/: KeyEvent.c Keyhandle.c KeyTasks.c
  group LcdModule
    ../LcdModule/: dvLcd.c LcdHandle.c LcdReceiveEvent.c
  group LedModule
    ../LedModule/: dvTM1623.c LedHandle.c LedReceiveEvent.c
  group MainApp
    ../mainAPP/: mainapp.c
  group NVRAMMoudle
    ../NVRAMModule/: dvNVRAM.c utilCRC.c utilDataMgr.c
  group Sii9679_App
    ../InputModule/: InputReceiveEvent.c
    ../InputModule/sii9679/application_9679/rx_example/: si_app_adapter_rx.c
  group Sii9679_Driver
    ../InputModule/sii9679/driver/adapter/adapter_api/: si_drv_adapter.c
    ../InputModule/sii9679/driver/adapter/adapter_internal/: si_drv_adapter_internal.c
    ../InputModule/sii9679/driver/adapter/adapter_rx/: si_drv_adapter_rx.c
    ../InputModule/sii9679/driver/adapter/adapter_tx/: si_drv_adapter_tx.c
  group StdPeriph_Driver
    ../../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group STM32_EVAL
    ../../../Utilities/STM32_EVAL/: stm32_eval.c
  group SwitchVideoModule
    ../SwitchVideoModule/: dvADN4604.c SwitchVideoHandle.c SwitchVideoReceiveEvent.c
  group USB-FS-Device_Driver
    ../../../Libraries/STM32_USB-FS-Device_Driver/src/: otgd_fs_cal.c otgd_fs_dev.c otgd_fs_int.c otgd_fs_pcd.c usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
    ../src/: usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group User
    ../src/: appPowerMgr.c appSystemMgr.c appUserInterface.c bsp_Gpio.c BSP_I2c.c dv74ls138.c dvCPLD.c dvPC9539.c dvVS010TX.c halPowerCtrl.c hw_config.c initPeriph.c main.c stm32f10x_it.c Uart2.c Util.c
  group UserRs323Module
    ../UserRs232Module/: uart.c UartRs232Tasks.c
